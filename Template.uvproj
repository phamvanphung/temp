# Keil uVision project Template.uvproj, settings and files
target Template (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: (Generic) M051 Series Nuvoton
  cpu: CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: template +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\CMSIS;.\Components;.\Library;.\User;.\CMSIS\inc;.\CMSIS\src;.\CMSIS\StartUp;.\Library\inc;.\Library\src;.\Components\ins;.\Components\src
  library: MicroLIB
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./CMSIS/src/: system_M051Series.c
    ./CMSIS/StartUp/: startup_M051Series.s
  group Library
    ./Library/src/: clk.c retarget.c sys.c uart.c timer.c
    D:/Nuvoton/project/Template/Keil/Library/src/: i2c.c
    ./Components/src/: I2C_custom.c
  group User
    ./User/: main.c task.c
  group Components
    ./Components/src/: clk_init.c DS1307.c
